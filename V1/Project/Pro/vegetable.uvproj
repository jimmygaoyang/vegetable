# Keil uVision project vegetable.uvproj, settings and files
target vegetable (ARM-ADS)
  device: STM32F103RB STMicroelectronics
  cpu: IRAM(0x20000000-0x20004FFF) IROM(0x8000000-0x801FFFF) CLOCK(8000000) CPUTYPE("Cortex-M3")
  output: vegetable
  c flags: Optim=1
  c define: STM32F10X_MD USE_STDPERIPH_DRIVER
  c include: ..\..\USER\inc;..\..\Libraries\CMSIS\CM3\CoreSupport;..\..\Libraries\CMSIS\CM3\DeviceSupport\ST\STM32F10x;..\..\Libraries\STM32F10x_StdPeriph_Driver\inc
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group USER
    ../../USER/src/: main.cpp usart.c DelayFun.c stm32f10x_it.c spi.c GlobalIOSet.cpp GlobalCtrlParament.cpp TransDataSubject.cpp ProtocolOberserver.cpp AutoCtrl.cpp CurrentStatue.cpp HotCtrl.cpp LightCtrl.cpp ModeCtrl.cpp WaterCtrl.cpp WindCtrl.cpp DHT.cpp
  group STM32_LIB
    ../../Libraries/STM32F10x_StdPeriph_Driver/src/: misc.c stm32f10x_gpio.c stm32f10x_rcc.c stm32f10x_usart.c stm32f10x_spi.c
  group MDK_STARTUP
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/startup/arm/: startup_stm32f10x_md.s
  group CMSIS
    ../../Libraries/CMSIS/CM3/CoreSupport/: core_cm3.c
    ../../Libraries/CMSIS/CM3/DeviceSupport/ST/STM32F10x/: system_stm32f10x.c
